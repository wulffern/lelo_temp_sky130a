v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0 {name=p0 lab=PWRUP_N_1V8}
C {devices/iopin.sym} 0 20 0 0 {name=p1 lab=VBP}
C {devices/iopin.sym} 0 40 0 0 {name=p2 lab=VD1}
C {devices/iopin.sym} 0 60 0 0 {name=p3 lab=VSS}
C {../design/LELO_TEMP_SKY130A/REYATR_NCH_4C5F0.sym} 400 0 0 0 {name=Xxnd1<0>}
C {../design/LELO_TEMP_SKY130A/REYATR_NCH_4C5F0.sym} 400 0 0 0 {name=Xxnd1<1>}
C {../design/LELO_TEMP_SKY130A/REYATR_NCH_4C5F0.sym} 400 0 0 0 {name=Xxnd1<2>}
C {../design/LELO_TEMP_SKY130A/REYATR_NCH_4C5F0.sym} 400 0 0 0 {name=Xxnd3}
C {../design/LELO_TEMP_SKY130A/REYATR_NCH_4C5F0.sym} 400 0 0 0 {name=Xxns1}
