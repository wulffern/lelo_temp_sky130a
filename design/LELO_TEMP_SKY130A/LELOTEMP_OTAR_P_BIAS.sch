v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0 {name=p0 lab=PWRUP_1V8}
C {devices/iopin.sym} 0 20 0 0 {name=p1 lab=PWRUP_N_1V8}
C {devices/iopin.sym} 0 40 0 0 {name=p2 lab=VBP}
C {devices/iopin.sym} 0 60 0 0 {name=p3 lab=VCP}
C {devices/iopin.sym} 0 80 0 0 {name=p4 lab=VDD_1V8}
C {devices/iopin.sym} 0 100 0 0 {name=p5 lab=VDS}
C {devices/iopin.sym} 0 120 0 0 {name=p6 lab=VO}
C {../design/LELO_TEMP_SKY130A/REYATR_PCH_11C5F0.sym} 400 0 0 0 {name=Xxba1}
C {../design/LELO_TEMP_SKY130A/REYATR_PCH_11C5F0.sym} 400 0 0 0 {name=Xxba2}
C {../design/LELO_TEMP_SKY130A/REYATR_PCH_11C5F0.sym} 400 0 0 0 {name=Xxba3}
C {../design/LELO_TEMP_SKY130A/REYATR_PCH_11C5F0.sym} 400 0 0 0 {name=Xxba6}
C {../design/LELO_TEMP_SKY130A/REYATR_PCH_11C5F0.sym} 400 0 0 0 {name=Xxba7}
C {../design/LELO_TEMP_SKY130A/REYATR_PCH_11C5F0.sym} 400 0 0 0 {name=Xxba8}
