v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0 {name=p0 lab=VD1}
C {devices/iopin.sym} 0 20 0 0 {name=p1 lab=VD3}
C {devices/iopin.sym} 0 40 0 0 {name=p2 lab=VDD_1V8}
C {devices/iopin.sym} 0 60 0 0 {name=p3 lab=VIN}
C {devices/iopin.sym} 0 80 0 0 {name=p4 lab=VS}
C {../design/LELO_TEMP_SKY130A/REYATR_LVT_PCH_11C5F0.sym} 400 0 0 0 {name=Xxbl1<0>}
C {../design/LELO_TEMP_SKY130A/REYATR_LVT_PCH_11C5F0.sym} 400 0 0 0 {name=Xxbl1<1>}
C {../design/LELO_TEMP_SKY130A/REYATR_LVT_PCH_11C5F0.sym} 400 0 0 0 {name=Xxbl1<2>}
C {../design/LELO_TEMP_SKY130A/REYATR_LVT_PCH_11C5F0.sym} 400 0 0 0 {name=Xxbl1<3>}
C {../design/LELO_TEMP_SKY130A/REYATR_LVT_PCH_11C5F0.sym} 400 0 0 0 {name=Xxbl1<4>}
C {../design/LELO_TEMP_SKY130A/REYATR_LVT_PCH_11C5F0.sym} 400 0 0 0 {name=Xxbl1<5>}
C {../design/LELO_TEMP_SKY130A/REYATR_LVT_PCH_11C5F0.sym} 400 0 0 0 {name=Xxbl4}
