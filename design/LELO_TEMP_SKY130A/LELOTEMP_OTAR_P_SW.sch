v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0 {name=p0 lab=VCP}
C {devices/iopin.sym} 0 20 0 0 {name=p1 lab=VDD_1V8}
C {LELO_TEMP_SKY130A/REYATR_PCH_4C1F2.sym} 400 0 0 0 {name=Xxbs1}
