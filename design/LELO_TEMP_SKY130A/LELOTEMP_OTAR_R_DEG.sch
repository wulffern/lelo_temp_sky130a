v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0 {name=p0 lab=VDS}
C {devices/iopin.sym} 0 20 0 0 {name=p1 lab=VS}
C {devices/iopin.sym} 0 40 0 0 {name=p2 lab=VSS}
C {../design/LELO_TEMP_SKY130A/REYATR_RES_36C2F0.sym} 400 0 0 0 {name=Xxd2<0>}
C {../design/LELO_TEMP_SKY130A/REYATR_RES_36C2F0.sym} 400 0 0 0 {name=Xxd2<1>}
